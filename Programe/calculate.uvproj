# Keil uVision project calculate.uvproj, settings and files
target Calculate (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: calculate +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\APP\lcd1602;.\APP\keyborad
  group User
    ./User/: main.c
    ./: STARTUP.A51
  group App
    ./APP/lcd1602/: lcd1602.c
    ./APP/keyborad/: keyboard.c
